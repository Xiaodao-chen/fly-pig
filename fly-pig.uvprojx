# Keil uVision project fly-pig.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sizhou
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,USE_HSE_BYPASS,STM32F401XX_HD
  c include: .\f401\FWLIB;.\BSP\include;.\f401\CMSIS;.\f401\STARTUP;.\Attitude_solving;.\ucos\source;.\ucos\port;.\USER;.\Sysemview\SEGGER;.\Sysemview\Sample\uCOS-II;.\Sysemview\Config;.\PID
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./USER/: main.c altitude.c
    ./Attitude_solving/: datafusion.c
    ./PID/: PID.c
  group startup
    ./f401/STARTUP/: startup_stm32f401xx.s
  group CMSIS
    ./f401/CMSIS/: system_stm32f4xx.c core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group lib
    ./f401/FWLIB/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group bsp/include
    ./BSP/include/: app_cfg.h app_hooks.c bsp_esp8266.h bsp_gy86.h bsp_i2c.h bsp_led.h bsp_oled.h bsp_ppm.h bsp_ray.h bsp_systick.h bsp_tim.h bsp_usart.h bsp_zifu.h os_cfg.h bsp_dma.h
  group bsp/source
    ./BSP/source/: bsp_gy86.c bsp_i2c.c bsp_led.c bsp_oled.c bsp_ppm.c bsp_ray.c bsp_tim.c bsp_usart.c bsp_dma.c
    ./USER/: ANO.c
  group ucos/source
    ./ucos/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group ucos/port
    ./ucos/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Systemview
    ./Sysemview/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
    ./Sysemview/Sample/uCOS-II/: SEGGER_SYSVIEW_uCOSII.c
    ./Sysemview/Sample/uCOS-II/Config/Cortex-M/: SEGGER_SYSVIEW_Config_uCOSII.c
    ./: segger_rtt_asm_armv7m.o
