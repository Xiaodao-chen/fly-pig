# Keil uVision project led.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,USE_HSE_BYPASS,STM32F401XX_HD
  c include: .\LED;.\f401\FWLIB;.\f401\CMSIS;.\f401\STARTUP;.\LED;.\USART;.\ESP8266;.\SYSTICK;.\TIM;.\I2C;.\OLED;.\GY86;.\PPM;.\Ray
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./USER/: main.c
    ./LED/: bsp_led.c
    ./USART/: bsp_usart.c
    ./ESP8266/: bsp_esp8266.c
    ./SYSTICK/: bsp_systick.c
    ./TIM/: bsp_tim.c
    ./I2C/: bsp_i2c.c
    ./OLED/: bsp_oled.c
    ./GY86/: bsp_gy86.c
    ./PPM/: bsp_ppm.c
    ./Ray/: bsp_ray.c
  group FWLIB
    ./f401/STARTUP/: startup_stm32f401xx.s
  group STARTUP
    ./f401/FWLIB/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ./f401/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
